# Keil uVision project STM32F030F4_Demo.uvprojx, settings and files
target STM32F030F4 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F0308_Discovery +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c misc: --c99
  c include: ..\STM32F030_FWLib\src;..\STM32F030_FWLib\inc;..\CORE;..\OBJ;..\USER;..\APPS;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group HARDWARE
    ../HARDWARE/: delay.c ADC1.c USART1.c
  group CORE
    ../CORE/: startup_stm32f030x8.s
  group STM32F0xx_StdPeriph_Driver
    ../STM32F030_FWLib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
software components: CMSIS:CORE 4.1.0
